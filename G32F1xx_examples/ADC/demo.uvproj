# Keil uVision project demo.uvproj, settings and files
target Run In Flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo +hex
  c flags: Optim=1
  c define: ENABLE_ADC
  c include: .\myapp\inc;..\..\G32F1xx_library\Drivers\include;..\..\G32F1xx_library\Core\CM3\DeviceSupport\G32F1xx;..\..\G32F1xx_library\Core\CM3\CoreSupport
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../../G32F1xx_library/Drivers/source/: gt_adc.c gt_gpio.c gt_sys.c gt_rcc.c
    ../../G32F1xx_library/Core/CM3/DeviceSupport/G32F1xx/Startup/rvds/: startup_G32F1xx_s.s
    ../../G32F1xx_library/Core/CM3/DeviceSupport/G32F1xx/: system_G32F1xx.c
  group App
    ./myapp/src/: main.c
target Run In RAM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo
  c flags: Optim=1
  c define: __UART0
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x800
