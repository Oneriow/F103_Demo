# Keil uVision project demo.uvproj, settings and files
target Run In Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\myapp\inc;..\..\G32F1xx_library\Drivers\include;..\..\G32F1xx_library\Core\CM3\DeviceSupport\G32F1xx;..\..\G32F1xx_library\Core\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Common
    ../../G32F1xx_library/Core/CM3/CoreSupport/: core_cm3.c
    ../../G32F1xx_library/Core/CM3/DeviceSupport/G32F1xx/: system_G32F1xx.c
    ../../G32F1xx_library/Core/CM3/DeviceSupport/G32F1xx/Startup/rvds/: startup_G32F1xx_s.s
    ../../G32F1xx_library/Drivers/source/: gt_gpio.c gt_sys.c gt_uart.c gt_rcc.c
  group App
    ./myapp/src/: main.c
target Run In RAM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __UART0
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
